COMPATIBLE_MACHINE = "(owa5x)"
