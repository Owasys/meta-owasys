IMAGE_INSTALL += "  owasysd-measured-boot \
"