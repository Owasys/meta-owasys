RDEPENDS:${PN}:remove = "\
    dhcpcd \
    "
